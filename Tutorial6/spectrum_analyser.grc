<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2417000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook</value></param>
<param><key>labels</key><value>['Frequency', 'Waterfall']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>bw0</key><value>20000000</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook, 0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook, 1</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_transceiver</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>0</value></param>
<param><key>labels</key><value>["LS", "LMS", "STA", "Linear Comb"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>0, 1, 3, 2</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>encoding</value></param>
<param><key>block_id</key><value>frequencyAdaptiveOFDM_mac_and_parse_0</value></param>
<param><key>function_name</key><value>get_encoding</value></param>
<param><key>value</key><value>[0,0,0,0,0]</value></param>
<param><key>poll_rate</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>5890000000</value></param>
<param><key>labels</key><value>['  1 | 2412.0 | 11g', '  2 | 2417.0 | 11g', '  3 | 2422.0 | 11g', '  4 | 2427.0 | 11g', '  5 | 2432.0 | 11g', '  6 | 2437.0 | 11g', '  7 | 2442.0 | 11g', '  8 | 2447.0 | 11g', '  9 | 2452.0 | 11g', ' 10 | 2457.0 | 11g', ' 11 | 2462.0 | 11g', ' 12 | 2467.0 | 11g', ' 13 | 2472.0 | 11g', ' 14 | 2484.0 | 11g', ' 34 | 5170.0 | 11a', ' 36 | 5180.0 | 11a', ' 38 | 5190.0 | 11a', ' 40 | 5200.0 | 11a', ' 42 | 5210.0 | 11a', ' 44 | 5220.0 | 11a', ' 46 | 5230.0 | 11a', ' 48 | 5240.0 | 11a', ' 50 | 5250.0 | 11a', ' 52 | 5260.0 | 11a', ' 54 | 5270.0 | 11a', ' 56 | 5280.0 | 11a', ' 58 | 5290.0 | 11a', ' 60 | 5300.0 | 11a', ' 62 | 5310.0 | 11a', ' 64 | 5320.0 | 11a', '100 | 5500.0 | 11a', '102 | 5510.0 | 11a', '104 | 5520.0 | 11a', '106 | 5530.0 | 11a', '108 | 5540.0 | 11a', '110 | 5550.0 | 11a', '112 | 5560.0 | 11a', '114 | 5570.0 | 11a', '116 | 5580.0 | 11a', '118 | 5590.0 | 11a', '120 | 5600.0 | 11a', '122 | 5610.0 | 11a', '124 | 5620.0 | 11a', '126 | 5630.0 | 11a', '128 | 5640.0 | 11a', '132 | 5660.0 | 11a', '134 | 5670.0 | 11a', '136 | 5680.0 | 11a', '138 | 5690.0 | 11a', '140 | 5700.0 | 11a', '142 | 5710.0 | 11a', '144 | 5720.0 | 11a', '149 | 5745.0 | 11a (SRD)', '151 | 5755.0 | 11a (SRD)', '153 | 5765.0 | 11a (SRD)', '155 | 5775.0 | 11a (SRD)', '157 | 5785.0 | 11a (SRD)', '159 | 5795.0 | 11a (SRD)', '161 | 5805.0 | 11a (SRD)', '165 | 5825.0 | 11a (SRD)', '172 | 5860.0 | 11p', '174 | 5870.0 | 11p', '176 | 5880.0 | 11p', '178 | 5890.0 | 11p', '180 | 5900.0 | 11p', '182 | 5910.0 | 11p', '184 | 5920.0 | 11p']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>6e6</value></param>
<param><key>option2</key><value>11e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>value</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1500</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
<param><key>labels</key><value>["5 MHz", "10 MHz", "20 MHz"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[5e6, 10e6, 20e6]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>adaptiveOFDM_stream_spacer</key>
<param><key>id</key><value>adaptiveOFDM_stream_spacer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interval</key><value>500</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/investigador/GNURadio/resources/wifi.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/investigador/GNURadio/resources/prueba_rx.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("".join("X" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>10</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>pdu_length</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>range(100)</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>pad_front</key><value>10000</value></param>
<param><key>pad_tail</key><value>10000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>frequencyAdaptiveOFDM_display_rate_file</key>
<param><key>id</key><value>frequencyAdaptiveOFDM_display_rate_file_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>display_file</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>read_file</key><value></value></param>
</block>
<block>
<key>frequencyAdaptiveOFDM_mac_and_parse</key>
<param><key>id</key><value>frequencyAdaptiveOFDM_mac_and_parse_0</value></param>
<param><key>rx_packets_f</key><value>/tmp/rx_packets.csv</value></param>
<param><key>tx_packets_f</key><value>/tmp/tx_packets.csv</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
<param><key>dst_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
<param><key>src_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
</block>
<block>
<key>frequencyAdaptiveOFDM_rb_const_demux_stream</key>
<param><key>id</key><value>frequencyAdaptiveOFDM_rb_const_demux_stream_0</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>frequencyAdaptiveOFDM_write_frame_data</key>
<param><key>id</key><value>frequencyAdaptiveOFDM_write_frame_data_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>enc_file</key><value>/tmp/encoding.csv</value></param>
<param><key>delay_file</key><value>/tmp/wifi_frame_delay.csv</value></param>
<param><key>snr_file</key><value>/tmp/snr.csv</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>label1</key><value>RB1</value></param>
<param><key>label2</key><value>RB2</value></param>
<param><key>label3</key><value>RB3</value></param>
<param><key>color4</key><value>"yellow"</value></param>
<param><key>label4</key><value>RB4</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>48*10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Error Rate</value></param>
<param><key>unit1</key><value>Percent</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Data Received"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>300000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>wifi_freq_adap_phy_hier</key>
<param><key>id</key><value>wifi_freq_adap_phy_hier_0_0</value></param>
<param><key>bandwidth</key><value>10e6</value></param>
<param><key>chan_est</key><value>0</value></param>
<param><key>delay_file</key><value>"/tmp/symbols_delay.csv"</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frequency</key><value>5.89e9</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<connection><source_block_id>adaptiveOFDM_stream_spacer_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</sink_block_id><source_key>pdus</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>adaptiveOFDM_stream_spacer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</sink_block_id><source_key>pdus</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>app out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</source_block_id><sink_block_id>frequencyAdaptiveOFDM_write_frame_data_0</sink_block_id><source_key>frame data</source_key><sink_key>frame data</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</source_block_id><sink_block_id>wifi_freq_adap_phy_hier_0_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_rb_const_demux_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_rb_const_demux_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_rb_const_demux_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>frequencyAdaptiveOFDM_rb_const_demux_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wifi_freq_adap_phy_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_freq_adap_phy_hier_0_0</source_block_id><sink_block_id>frequencyAdaptiveOFDM_rb_const_demux_stream_0</sink_block_id><source_key>carrier</source_key><sink_key>symbols_in</sink_key></connection>
<connection><source_block_id>wifi_freq_adap_phy_hier_0_0</source_block_id><sink_block_id>frequencyAdaptiveOFDM_mac_and_parse_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_freq_adap_phy_hier_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
